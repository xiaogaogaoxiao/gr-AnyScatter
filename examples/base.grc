options:
  parameters:
    generate_options: no_gui
    id: AnyScatterGRC
    output_language: python
    realtime_scheduling: '1'
    title: AnyScatterGRC
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 2450e6
  states: {}
- name: num_antennas
  id: variable
  parameters:
    value: '4'
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '25'
  states: {}
- name: rx_rate
  id: variable
  parameters:
    value: 50e6
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: tag_rate
  id: variable
  parameters:
    value: 62.5e3
  states: {}
- name: AnyScatter_decimator_0
  id: AnyScatter_decimator
  parameters:
    num_antennas: num_antennas
    sample_rate: rx_rate
    symbol_rate: symbol_rate
  states: {}
- name: AnyScatter_demodulator_0
  id: AnyScatter_demodulator
  parameters:
    num_antennas: num_antennas
    symbol_rate: symbol_rate
    tag_rate: tag_rate
  states: {}
- name: uhd_usrp_source
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    ant1: RX2
    ant2: RX2
    ant3: RX2
    bw0: rx_rate
    bw1: rx_rate
    bw2: rx_rate
    bw3: rx_rate
    center_freq0: center_freq
    center_freq1: center_freq
    center_freq2: center_freq
    center_freq3: center_freq
    clock_source1: external
    dc_offs_enb0: 'True'
    dc_offs_enb1: 'True'
    dc_offs_enb2: 'True'
    dc_offs_enb3: 'True'
    dev_addr: '"addr0=192.168.40.2,addr1=192.168.41.2"'
    dev_args: '""'
    gain0: rx_gain
    gain1: rx_gain
    gain2: rx_gain
    gain3: rx_gain
    iq_imbal_enb0: 'True'
    iq_imbal_enb1: 'True'
    iq_imbal_enb2: 'True'
    iq_imbal_enb3: 'True'
    nchan: '4'
    norm_gain0: 'False'
    norm_gain1: 'False'
    norm_gain2: 'False'
    norm_gain3: 'False'
    num_mboards: '2'
    rx_agc2: Default
    rx_agc3: Default
    samp_rate: rx_rate
    sync: sync
    time_source1: external
    type: fc32
  states: {}

connections:
- [AnyScatter_decimator_0, '0', AnyScatter_demodulator_0, '0']
- [uhd_usrp_source, '0', AnyScatter_decimator_0, '0']
- [uhd_usrp_source, '1', AnyScatter_decimator_0, '1']
- [uhd_usrp_source, '2', AnyScatter_decimator_0, '2']
- [uhd_usrp_source, '3', AnyScatter_decimator_0, '3']

metadata:
  file_format: 1
